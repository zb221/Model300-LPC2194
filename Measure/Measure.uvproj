# Keil uVision project Measure.uvproj, settings and files
target LPC2129 Simulator (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Measure
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c Serial.c
  group Source Code
    ./: Measure.c Mcommand.c Getline.c
  group Documentation
    ./: Abstract.txt
target MCB2100 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: as above
  output: Measure
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
target MCB2130 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC2194 NXP
  cpu: as above
  output: Measure +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
